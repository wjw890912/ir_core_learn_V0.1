# Keil uVision project IR_RAW.uvproj, settings and files
target IR_RAW (ARM-ADS)
  device: M058LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: IR_RAW +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\CMSIS\CM0\CoreSupport;..\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;..\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series\startup\arm;..\FMC;..\GPIO;..\Include;..\MAIN;..\USART;..\WDT;..\红外;..\SI4432_Driver;..\SI4432Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ../MAIN/: main.c
  group LIB
    ../Lib/: DrvADC.c DrvFMC.c DrvGPIO.c DrvI2C.c DrvPWM.c DrvEBI.c DrvSPI.c DrvSYS.c DrvTIMER.c DrvUART.c retarget.c
  group CMSIS
    ../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ../CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
  group GPIO
    ../GPIO/: GPIO.c
  group IR
    ../红外/: ir.c Flash_Memory.c
    ../FMC/: FMC.c
  group SI4432
    ../SI4432_Driver/: SI4432.c
    ../SI4432Protocol/: SI4432_proto.c
